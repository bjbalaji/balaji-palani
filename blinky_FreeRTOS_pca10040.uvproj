# Keil uVision project blinky_FreeRTOS_pca10040.uvproj, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: NRF52832 NRF52 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 CONFIG_GPIO_AS_PINRESET NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 FREERTOS
  c misc: --c99
  c include: ..\..\..\config\blinky_FreeRTOS_pca10040;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\toolchain;..\..\..;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\..\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DNRF52832,-DNRF52,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DFREERTOS
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../../: license.txt
  group Third Parties
    ../../../../../../external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../external/freertos/source/portable/MemMang/: heap_1.c
    ../../../../../../external/freertos/portable/ARM/nrf52/: port.c
    ../../../../../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../../../../../components/libraries/timer/: app_timer_freertos.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
